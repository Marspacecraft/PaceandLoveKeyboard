# Keil uVision project PaceAndLoveKeyboard.uvprojx, settings and files
target PaceAndLoveKeyboard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: PaceAndLoveKeyboard +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../OBJ/PALK.bin ./PaceAndLoveKeyboard/PaceAndLoveKeyboard.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../CherryUSB;../Core/Keyboard/74hc165;../Core/Keyboard/keylayer;../Core/Keyboard/keyboard;../Core/Led;../Core/Flash;../Fatfs;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../SFUD;../Core/Epaper;../Core/Epaper/ePaper;../Core/joystick;../Core/Epaper/lcd;../Core/Fronts;../Ymodem;../Core/Oled
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: tracelog.c scheduler.c timertask.c timeradc.c main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Core/joystick/: joystick.c
    ../Core/Epaper/lcd/: st7302.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group CherryUSB
    ../CherryUSB/class/: usbd_cdc.c usbd_hid.c
    ../CherryUSB/core/: usb_dc_fsdev.c usbd_core.c
    ../CherryUSB/: usbd_agent.c
  group Keyboard/74hc165d
    ../Core/Keyboard/74hc165/: 74hc165d.c
  group Keyboard/keyboard
    ../Core/Keyboard/keyboard/: keyboard.c
  group Keyboard/keylayer
    ../Core/Keyboard/keylayer/: keylayer.c
  group Application/User/Led
    ../Core/Led/: ws2812b.c rgb.c rgbmode.c
  group Application/User/Flash
    ../Core/Flash/: memery.c
  group Fatfs
    ../Fatfs/: diskio.c ff.c ffsystem.c ffunicode.c fatfs.c
  group SFUD
    ../SFUD/: bsp_spi_flash.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Application/User/Epaper
    ../Core/Epaper/: bmpdecode.c
    ../Core/Epaper/ePaper/: DEV_Config.c EPD_2in7_V2.c
  group Application/User/Fonts
    ../Core/Fronts/: fonts.c gt20.c
  group Ymodem
    ../Ymodem/: common.c menu.c ymodem.c
  group Application/User/Oled
    ../Core/Oled/: oled.c
software components: CMSIS:CORE 4.3.0
